## examples/periph/P-04_battery_voltage/sdkconfig.defaults
```kconfig
# XIAO ESP32-S3：USB-Serial-JTAG 控制台
CONFIG_IDF_TARGET="esp32s3"
CONFIG_ESP_CONSOLE_USB_SERIAL_JTAG=y
```
